Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\jopel\OneDrive - Bayou Metal Supply\Documents\Delete_Me\Aceleds\AC15CD350AT2S\AC15CD350AT2S.IFC
Time: 2025-05-14T11:47:57+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
